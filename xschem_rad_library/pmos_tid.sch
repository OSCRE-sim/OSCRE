v {xschem version=3.4.5 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
C {rad_modeling/xschem_rad_library/devices/vsource.sym} 80 -70 0 0 {name=V2 value=\{v_bias\} savecurrent=false}
C {rad_modeling/xschem_rad_library/devices/ipin.sym} 80 -100 0 0 {name=p3 lab=in}
C {rad_modeling/xschem_rad_library/devices/opin.sym} 80 -40 0 0 {name=p4 lab=gate}
