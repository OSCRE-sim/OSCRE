** sch_path: /home/collinml/OSCRE/latchup/advanced_test.sch
**.subckt advanced_test
Q3 net3 VBD VDD pnp_cust area=1 m=1
Q4 net4 VBP VDD pnp_cust area=1 m=1
R7 VBP VBD 5 m=1
R8 VDD VBP 1000 m=1
R9 net4 net3 1 m=1
R10 VBD net2 5 m=1
R11 VBD net1 5 m=1
Q5 net2 net5 VDD npn_cust area=1 m=1
Q6 net1 VBN VSS npn_cust area=1 m=1
R12 net3 net5 1 m=1
R13 net5 VBN 1 m=1
R14 VBN VSS 1000 m=1
V1 VDD GND 5
V2 VSS GND 0
x3 VBP net4 double_exp t_r=5n tau_r=100p t_f=10n tau_f=100p q_tot=5.75p
**** begin user architecture code

.options savecurrents
.ic V(VBP)=5 V(VBN)=0
.tran 1p 15n 0n
.save all

.include /usr/local/share/rad_modeling_blocks/rad_modeling_blocks.spice

.model npn_cust npn (IS=1e-18 BF=100 VAF=50 IKF=0.01 CJE=0.2p CJC=0.1p TF=0.2n TR=2n)
.model pnp_cust pnp (IS=1e-18 BF=100 VAF=50 IKF=0.01 CJE=0.3p CJC=0.15p TF=0.3n TR=3n)

**** end user architecture code
**.ends
.GLOBAL GND
.end
