v {xschem version=3.4.5 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
C {rad_modeling/xschem_rad_library/devices/vsource.sym} 220 -140 0 0 {name=V2 value=\{v_bias\} savecurrent=false}
C {rad_modeling/xschem_rad_library/devices/opin.sym} 220 -170 0 0 {name=p3 lab=gate}
C {rad_modeling/xschem_rad_library/devices/ipin.sym} 220 -110 0 0 {name=p4 lab=in}
