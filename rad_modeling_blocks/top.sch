v {xschem version=3.4.5 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
T {Copy this block into any project that uses radiation modeling blocks} 30 -190 0 0 0.4 0.4 {}
C {code.sym} 20 -130 0 0 {name=include only_toplevel=false value="
.include /usr/local/share/rad_modeling_blocks/rad_modeling_blocks.spice
"}
