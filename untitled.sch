v {xschem version=3.4.5 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
C {npn.sym} 170 50 0 0 {name=Q1
model=MMBT2222
device=MMBT2222
footprint=SOT23
area=1
m=1}
