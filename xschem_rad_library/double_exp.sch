v {xschem version=3.4.5 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
C {rad_modeling/xschem_rad_library/devices/isource.sym} 60 -70 0 0 {name=I1 value="EXP(0 \{q_tot / (t_f-t_r+tau_f-tau_r)\} \{t_r\} \{tau_r\} \{t_f\} \{tau_f\})"}
C {rad_modeling/xschem_rad_library/devices/opin.sym} 60 -40 0 0 {name=p3 lab=OUT}
C {rad_modeling/xschem_rad_library/devices/ipin.sym} 60 -100 0 0 {name=p4 lab=IN}
