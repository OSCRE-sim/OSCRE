v {xschem version=3.4.5 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
C {RAD-HARD/lib/Organize_into_Examples_or_pdk_examples/xschem_rad_library/devices/vsource_arith.sym} 190 -90 0 0 {name=E1 VOL=Vnom-(Vnom/(1+exp(-k*(abs(I(E1))-X0))))}
C {RAD-HARD/lib/Organize_into_Examples_or_pdk_examples/xschem_rad_library/devices/ipin.sym} 190 -60 0 0 {name=p1 lab=NEGATIVE}
C {RAD-HARD/lib/Organize_into_Examples_or_pdk_examples/xschem_rad_library/devices/opin.sym} 190 -120 0 0 {name=p2 lab=POSITIVE}
